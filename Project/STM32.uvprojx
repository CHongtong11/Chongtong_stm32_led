# Keil uVision project STM32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\relay;..\User\shake;..\User\exti;..\User\usart;..\User\led;..\User\tim;..\User\motor;..\SYSTEM;..\User\HC_SR04;..\User\LED;..\User\Bear;..\User\key;..\User\exti;..\User\usart;..\User\tim;..\User\motor;..\User\motor;..\SYSTEM;..\User\HC_SR04;..\User\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/LED/: led.c
    ../User/usart/: usart.c
    ../User/tim/: tim.c
    ../User/oled/: oled.c
    ./: led.h
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group DOC
    ../Doc/: readme.txt
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/: SysTick.c
